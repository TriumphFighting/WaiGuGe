# Keil uVision project Test.uvprojx, settings and files
target ROBET (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SEM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\HAREWARE\KEY;..\HAREWARE\LED;..\SYSTEM\delay;..\HAREWARE\TIMER;..\HAREWARE\PWM;..\HAREWARE\USART;..\HAREWARE\FOOT;..\HAREWARE\MOTOR;..\HAREWARE\USART2;..\HAREWARE\USART1;..\HAREWARE\USART3;..\HAREWARE\TIMER5;..\HAREWARE\USART4;..\HAREWARE\USART5;..\HAREWARE\PID;..\HAREWARE\MOTOR2;..\HAREWARE\BEEP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HAERWARE
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/LED/: led.c
    ../HAREWARE/TIMER/: timer.c
    ../HAREWARE/PWM/: pwm.c
    ../HAREWARE/FOOT/: foot.c
    ../HAREWARE/MOTOR/: motor.c
    ../HAREWARE/USART2/: usart2.c
    ../HAREWARE/USART1/: usart1.c
    ../HAREWARE/USART3/: usart3.c
    ../HAREWARE/TIMER5/: timer5.c
    ../HAREWARE/USART4/: usart4.c
    ../HAREWARE/USART5/: usart5.c
    ../HAREWARE/BEEP/: beep.c
